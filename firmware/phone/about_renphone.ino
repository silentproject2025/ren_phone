// =====================================================================
// about_renphone.ino -- app ABOUT PHONE (SCR_ABOUT) untuk Accretion Phone / NyxOS
// =====================================================================
// Isi halaman:
//   * Kartu identitas : "Accretion Phone" + "NyxOS" + versi firmware
//   * Daftar info     : chip, CPU, suhu, flash, RAM internal, PSRAM, SD Card,
//                       layar, baterai, WiFi (SSID/IP/MAC), uptime, build
//   * Bisa di-scroll dengan drag jari, tombol Kembali seperti app lain.
//
// ATURAN PROYEK YANG DIIKUTI (lihat komentar panjang di phone.ino):
//   - TIDAK ada String yang dibuat tiap frame (RAM internal cuma ~162KB dan
//     gampang terfragmentasi). Semua teks dibangun SEKALI per detik ke buffer
//     char statis lewat aboutRefresh(), drawAbout() hanya membaca buffer itu.
//   - Semua fungsi publik hanya menerima tipe primitif / LGFX_Sprite&, supaya
//     tidak kena bug prototype otomatis arduino-cli (kasus MazeGhost dkk).
//   - Layout dihitung dari SCR_W/SCR_H, jadi jalan di landscape & portrait.
//   - Tidak ada alokasi heap sama sekali di app ini.
//
// DIPASANG ke phone.ino lewat apply_about_patch.py:
//   enum Screen      <- SCR_ABOUT
//   apps[] + warna   <- { "About Phone", 'i', ... }
//   drawAppIcon()    <- case 'i'
//   loop()           <- aboutLoopPoll()  (refresh tiap 1 detik saat app terbuka)
// =====================================================================

// ---- identitas (ubah di sini kalau ganti nama / versi) ----
#define ABOUT_DEVICE_NAME  "Accretion Phone"
#define ABOUT_OS_NAME      "NyxOS"
#define ABOUT_FW_VERSION   "v119"      // samakan dengan nomor versi terakhir di komentar phone.ino
#define ABOUT_BOARD_NAME   "ESP32-S3 + ILI9341"

#define ABOUT_MAX_ROWS     32
#define ABOUT_KEY_LEN      18
#define ABOUT_VAL_LEN      44

struct AboutRow { char k[ABOUT_KEY_LEN]; char v[ABOUT_VAL_LEN]; };

static AboutRow aboutRows[ABOUT_MAX_ROWS];
static int      aboutRowN       = 0;
static float    aboutScroll     = 0;      // px, 0 = paling atas
static int      aboutMaxScroll  = 0;
static int      aboutLastY      = 0;
static bool     aboutDragging   = false;
static unsigned long aboutLastPoll = 0;

// ---------------------------------------------------------------------
// util kecil
// ---------------------------------------------------------------------
static void aboutAdd(const char* k, const char* v) {
  if (aboutRowN >= ABOUT_MAX_ROWS) return;
  strncpy(aboutRows[aboutRowN].k, k, ABOUT_KEY_LEN - 1);
  aboutRows[aboutRowN].k[ABOUT_KEY_LEN - 1] = 0;
  strncpy(aboutRows[aboutRowN].v, v, ABOUT_VAL_LEN - 1);
  aboutRows[aboutRowN].v[ABOUT_VAL_LEN - 1] = 0;
  aboutRowN++;
}

static void aboutFmtBytes(char* out, size_t n, uint64_t b) {
  if (b >= (1ULL << 30))      snprintf(out, n, "%.2f GB", (double)b / (1024.0 * 1024.0 * 1024.0));
  else if (b >= (1ULL << 20)) snprintf(out, n, "%.1f MB", (double)b / (1024.0 * 1024.0));
  else                        snprintf(out, n, "%u KB", (unsigned)(b / 1024ULL));
}

static void aboutFmtUptime(char* out, size_t n, unsigned long ms) {
  unsigned long s = ms / 1000UL;
  unsigned long d = s / 86400UL; s %= 86400UL;
  unsigned long h = s / 3600UL;  s %= 3600UL;
  unsigned long m = s / 60UL;    s %= 60UL;
  if (d > 0) snprintf(out, n, "%lu hr %lu j %lu m", d, h, m);
  else if (h > 0) snprintf(out, n, "%lu j %lu m %lu d", h, m, s);
  else snprintf(out, n, "%lu m %lu d", m, s);
}

// Bangun ulang seluruh baris info. Dipanggil saat app dibuka & tiap ~1 detik.
static void aboutRefresh() {
  char a[ABOUT_VAL_LEN], b[24], c[24];
  aboutRowN = 0;

  aboutAdd("Perangkat", ABOUT_DEVICE_NAME);
  aboutAdd("Sistem", ABOUT_OS_NAME);
  aboutAdd("Pemilik", ownerName());
  { char vl[16]; otaVersionLabel(vl, sizeof(vl)); int bn = otaBuildNum();
    if (bn > 0) snprintf(a, sizeof(a), "%s (build %d)", vl, bn); else snprintf(a, sizeof(a), "%s", vl); }
  aboutAdd("Versi firmware", a);
  snprintf(a, sizeof(a), "%s %s", __DATE__, __TIME__);
  aboutAdd(RPTR("Waktu build"), a);
  aboutAdd("Papan", ABOUT_BOARD_NAME);

  // ---- chip & CPU ----
  snprintf(a, sizeof(a), "%s rev %d, %d core", ESP.getChipModel(), (int)ESP.getChipRevision(), (int)ESP.getChipCores());
  aboutAdd("Chip", a);
  snprintf(a, sizeof(a), "%u MHz", (unsigned)ESP.getCpuFreqMHz());
  aboutAdd("CPU", a);
  snprintf(a, sizeof(a), "%.1f C", temperatureRead());
  aboutAdd("Suhu chip", a);

  // ---- memori ----
  aboutFmtBytes(a, sizeof(a), ESP.getFlashChipSize());
  aboutAdd("Flash", a);
  aboutFmtBytes(b, sizeof(b), ESP.getSketchSize());
  aboutFmtBytes(c, sizeof(c), ESP.getFreeSketchSpace());
  snprintf(a, sizeof(a), "%s / sisa %s", b, c);
  aboutAdd("Firmware", a);

  aboutFmtBytes(b, sizeof(b), heap_caps_get_free_size(MALLOC_CAP_INTERNAL));
  aboutFmtBytes(c, sizeof(c), ESP.getHeapSize());
  snprintf(a, sizeof(a), "%s bebas / %s", b, c);
  aboutAdd("RAM internal", a);

  size_t psTotal = ESP.getPsramSize();
  if (psTotal > 0) {
    aboutFmtBytes(b, sizeof(b), ESP.getFreePsram());
    aboutFmtBytes(c, sizeof(c), psTotal);
    snprintf(a, sizeof(a), "%s bebas / %s", b, c);
  } else {
    snprintf(a, sizeof(a), "%s", RPTR("Tidak terdeteksi"));
  }
  aboutAdd("PSRAM", a);

  // ---- SD Card ----
  if (sdReady) {
    aboutFmtBytes(b, sizeof(b), SD_MMC.usedBytes());
    aboutFmtBytes(c, sizeof(c), SD_MMC.totalBytes());
    snprintf(a, sizeof(a), "%s terpakai / %s", b, c);
  } else {
    snprintf(a, sizeof(a), "%s", RPTR("Tidak terdeteksi"));
  }
  aboutAdd("SD Card", a);

  // ---- layar & baterai ----
  aboutAdd(RPTR("Layar"), RP_DISP_NAME);
  snprintf(a, sizeof(a), "%d%% (%.2f V)", battPercent, battVoltage);
  aboutAdd(RPTR("Baterai"), a);

  // ---- WiFi ----
  if (WiFi.status() == WL_CONNECTED) {
    String ssid = WiFi.SSID();
    snprintf(a, sizeof(a), "%s", ssid.c_str());
    aboutAdd("WiFi", a);
    IPAddress ip = WiFi.localIP();
    snprintf(a, sizeof(a), "%u.%u.%u.%u", ip[0], ip[1], ip[2], ip[3]);
    aboutAdd("Alamat IP", a);
  } else {
    aboutAdd("WiFi", RPTR("Tidak tersambung"));
  }
  uint64_t mac = ESP.getEfuseMac();
  snprintf(a, sizeof(a), "%02X:%02X:%02X:%02X:%02X:%02X",
           (unsigned)(mac >> 0) & 0xFF, (unsigned)(mac >> 8) & 0xFF, (unsigned)(mac >> 16) & 0xFF,
           (unsigned)(mac >> 24) & 0xFF, (unsigned)(mac >> 32) & 0xFF, (unsigned)(mac >> 40) & 0xFF);
  aboutAdd("MAC", a);

  nyxAboutRows();   // NYX-EXTRAS-V1: reset terakhir, layar & RAM saat crash, backtrace
  aboutFmtUptime(a, sizeof(a), millis());
  aboutAdd(RPTR("Waktu aktif"), a);
}

// ---------------------------------------------------------------------
// geometri (dipakai bareng drawAbout() & aboutTouch())
// ---------------------------------------------------------------------
#define ABOUT_ROW_H   20
#define ABOUT_CARD_H  56

static int aboutListTop()    { return 26 + 18 + ABOUT_CARD_H + 8; }          // di bawah judul + kartu identitas
static int aboutListBottom() { return SCR_H - BACK_H - 3 - 6; }              // di atas tombol Kembali

static void aboutClampScroll() {
  int contentH = aboutRowN * ABOUT_ROW_H;
  int viewH = aboutListBottom() - aboutListTop();
  aboutMaxScroll = contentH - viewH;
  if (aboutMaxScroll < 0) aboutMaxScroll = 0;
  if (aboutScroll < 0) aboutScroll = 0;
  if (aboutScroll > aboutMaxScroll) aboutScroll = (float)aboutMaxScroll;
}

// =====================================================================
// EASTER EGG (EGG_ABOUT_V1): ketuk kartu identitas "Accretion Phone" 7x
// berturut-turut (jeda < 1,5 dtk antar ketukan) -> halaman cerita tersembunyi.
//   * tampilan TERMINAL: latar hitam, prompt hijau, perintah diketik lalu teks keluar
//     pelan-pelan, kursor berkedip; ketuk layar untuk melewati animasi
//   * bisa di-scroll; tombol Kembali menutup cerita (bukan keluar dari About)
//   * TIDAK ada alokasi heap, semua teks ASCII (font bawaan tidak punya tanda
//     pisah panjang / emoji). Teks disimpan TERACAK (XOR) di EGG_BLOB[] -- ubah
//     lewat egg_encode.py (lihat file itu), jangan diedit manual.
// =====================================================================
#define EGG_MAX_LINES  140
#define EGG_LINE_H     11
#define EGG_MAX_PARA   720
#define EGG_CPS        140          // kecepatan ketik isi cerita (karakter per detik)
#define EGG_CMD_CPS    30           // kecepatan ketik perintah di baris pertama
#define EGG_PAUSE_MS   400          // jeda setelah perintah, sebelum teks keluar
#define EGG_PROMPT     "nyx:~$ "
#define EGG_CMD        "cat fase_berkesan.log"
#define EGG_C_BG       0x0000       // hitam
#define EGG_C_BAR      0x2104       // abu gelap (bar judul)
#define EGG_C_BARTXT   0xBDF7
#define EGG_C_PROMPT   0x07E0       // hijau terminal
#define EGG_C_TEXT     0xBFF7       // hijau-putih lembut
#define EGG_C_WARN     0xFD20       // amber

// EGG_DATA_BEGIN
#define EGG_PN 5
static const uint16_t EGG_PO[] = {0, 424, 948, 1470, 1647};
static const uint16_t EGG_PL[] = {424, 524, 522, 177, 432};
static const uint8_t EGG_BLOB[] = {
  0x1B, 0xB5, 0x37, 0xCB, 0x69, 0xF0, 0x92, 0x42, 0x59, 0xE5, 0x3D, 0x1A, 0x84, 0xF5, 0x48, 0x2A,
  0xE3, 0xCF, 0x69, 0x27, 0xA2, 0x0F, 0x3E, 0x9F, 0xC8, 0xA7, 0xB4, 0xA7, 0x6F, 0xD2, 0x0B, 0xFC,
  0xF0, 0x77, 0x34, 0x29, 0x8D, 0x59, 0x60, 0x53, 0x04, 0xC9, 0x9A, 0xB1, 0xF9, 0x88, 0xF6, 0xD9,
  0x69, 0xEE, 0xF3, 0x95, 0x87, 0x3B, 0x64, 0xDF, 0xB7, 0x3B, 0xAA, 0xA1, 0xAE, 0xCC, 0xA6, 0xA9,
  0x1A, 0x08, 0xA9, 0x5A, 0xA8, 0xEA, 0x94, 0x9D, 0x56, 0x2F, 0x92, 0x16, 0x9D, 0xE4, 0xE1, 0xFB,
  0xA1, 0xD2, 0xB3, 0x89, 0xE2, 0xA4, 0x29, 0xC6, 0x17, 0x04, 0x24, 0xAC, 0xE5, 0x24, 0xCE, 0x44,
  0x59, 0xF9, 0xF3, 0x3B, 0xBF, 0x11, 0x96, 0x7E, 0x50, 0xD9, 0x23, 0xA9, 0xA8, 0x21, 0x85, 0x49,
  0x88, 0xC4, 0x5E, 0xD9, 0xF1, 0x8B, 0x31, 0x23, 0x2D, 0xAB, 0xB2, 0xC3, 0x9A, 0x07, 0x13, 0x29,
  0x38, 0xAC, 0x7A, 0x2F, 0x14, 0xEE, 0x99, 0x56, 0x8B, 0x55, 0x6A, 0xD3, 0xDE, 0x11, 0x17, 0x35,
  0xE1, 0xC3, 0x70, 0xF7, 0xDE, 0x0E, 0xEA, 0xC4, 0x9A, 0x6B, 0x2B, 0x21, 0xAB, 0x1F, 0x9E, 0xC3,
  0x0E, 0x47, 0xE5, 0x41, 0x7B, 0xF3, 0x4D, 0x71, 0xD0, 0x33, 0x24, 0xDD, 0x1A, 0xBC, 0x5D, 0x9D,
  0x70, 0x6E, 0x55, 0x8E, 0xC3, 0xAB, 0xC6, 0xEA, 0xCE, 0xD4, 0x3D, 0x71, 0xDE, 0x11, 0x7D, 0x25,
  0xD6, 0xBD, 0xC0, 0xFB, 0x7F, 0xA4, 0x37, 0x8E, 0xCE, 0x4F, 0x2E, 0x30, 0x27, 0x4E, 0xC8, 0x25,
  0x17, 0x26, 0x4A, 0x1A, 0xEA, 0x39, 0x11, 0x6F, 0x1D, 0x33, 0xB9, 0x29, 0xB3, 0x0C, 0x25, 0xD5,
  0xD1, 0xF9, 0x78, 0x8E, 0xB1, 0x35, 0xF4, 0xCD, 0x44, 0xBC, 0x5E, 0xBE, 0x63, 0x16, 0xA6, 0x87,
  0x7F, 0x64, 0xBF, 0xC4, 0xEC, 0xDC, 0x72, 0xF2, 0xCA, 0x3C, 0xC0, 0xA2, 0x9C, 0xB7, 0xEA, 0xAC,
  0xDA, 0xDD, 0xCA, 0xCD, 0x65, 0xBD, 0xFB, 0x1F, 0xCA, 0xE2, 0x12, 0x6B, 0x09, 0xD7, 0xE1, 0x7B,
  0x05, 0xB8, 0x5C, 0x3C, 0x12, 0x3C, 0xD5, 0xA2, 0x42, 0xD8, 0x66, 0x17, 0xF2, 0xF7, 0x98, 0xB7,
  0x6D, 0x1E, 0x5B, 0x06, 0xCB, 0x64, 0xF2, 0xE2, 0xE4, 0xC2, 0x64, 0x9C, 0xA2, 0x8D, 0x48, 0x4C,
  0x3D, 0x29, 0xDF, 0xA0, 0x14, 0xD1, 0x65, 0x1A, 0x17, 0x94, 0x7F, 0x14, 0x89, 0xFA, 0x86, 0xCC,
  0x81, 0x04, 0x7F, 0x0B, 0x91, 0xF6, 0xA3, 0x3E, 0x1D, 0x4E, 0xAB, 0x5B, 0xC5, 0x74, 0x18, 0x46,
  0x76, 0x21, 0xC1, 0x19, 0x3D, 0x19, 0xA0, 0xF0, 0x4D, 0x72, 0x6C, 0xED, 0x9C, 0x79, 0x47, 0xF2,
  0x11, 0x90, 0xBB, 0x65, 0xDD, 0xB1, 0x27, 0x46, 0xA0, 0xB4, 0xD4, 0x41, 0x5A, 0x94, 0xF5, 0x95,
  0x58, 0xB1, 0xF6, 0x3A, 0xEF, 0xC7, 0xA9, 0x20, 0x66, 0x12, 0x8C, 0x15, 0xFC, 0xD2, 0x31, 0x1F,
  0x0E, 0x3B, 0x22, 0x5D, 0x98, 0xF4, 0x91, 0x2D, 0x82, 0xD5, 0xC4, 0xA0, 0x3B, 0x12, 0xB4, 0x3B,
  0x28, 0x73, 0xF1, 0x4C, 0xFD, 0xC1, 0x08, 0x9C, 0xA2, 0xF9, 0x67, 0x5F, 0xB4, 0x12, 0x24, 0x7E,
  0x2B, 0x4E, 0xFE, 0x1B, 0x38, 0xEF, 0xA5, 0xC9, 0xDC, 0x73, 0x9D, 0xCE, 0xFE, 0x10, 0x55, 0x78,
  0x7A, 0x28, 0x71, 0x6C, 0xDD, 0x73, 0x09, 0x0D, 0xB8, 0xD9, 0x23, 0x14, 0x16, 0x64, 0x56, 0x6D,
  0x1A, 0x30, 0x26, 0xBB, 0x94, 0xB6, 0x56, 0xD7, 0x31, 0xF1, 0x00, 0x2F, 0x1C, 0x86, 0x28, 0x63,
  0xDA, 0x14, 0x04, 0x7F, 0xB2, 0xD1, 0x2A, 0xD1, 0x0D, 0x05, 0x68, 0x10, 0x1C, 0xA0, 0x8E, 0xD2,
  0x3E, 0xC4, 0x67, 0xA6, 0xFA, 0x28, 0xD8, 0x09, 0xF2, 0x30, 0xB0, 0x63, 0xFF, 0x65, 0x1D, 0xBF,
  0xF2, 0x99, 0x3F, 0xAB, 0x15, 0x44, 0xF2, 0x7D, 0xF4, 0x46, 0x8E, 0x38, 0xE2, 0x3D, 0x6C, 0x91,
  0xE2, 0x41, 0xCE, 0x74, 0xFA, 0x4C, 0x4D, 0x51, 0x1E, 0x09, 0x3F, 0xDB, 0xFB, 0x50, 0x1E, 0x19,
  0xCC, 0x58, 0x40, 0xE9, 0x69, 0x4E, 0x16, 0x3E, 0x51, 0x5C, 0xCC, 0x12, 0xAC, 0x37, 0x40, 0x48,
  0xC7, 0x95, 0xE7, 0x48, 0xB5, 0x15, 0xDD, 0x16, 0x26, 0xE3, 0xFB, 0xB8, 0x27, 0xC1, 0x0D, 0xF1,
  0xC5, 0x37, 0x77, 0xEA, 0x95, 0xE2, 0x05, 0xA5, 0xE7, 0xFB, 0x09, 0x71, 0x01, 0xA5, 0x8C, 0x6E,
  0x43, 0x9C, 0x9D, 0x7F, 0x54, 0x0B, 0xEE, 0x05, 0xF6, 0xE2, 0xF7, 0xF7, 0xA0, 0x4E, 0x8B, 0x6A,
  0x7D, 0xF1, 0x27, 0x16, 0xA9, 0x0A, 0xCC, 0xFF, 0x2B, 0x84, 0xD1, 0xC9, 0x71, 0x63, 0x84, 0x36,
  0x9B, 0xF5, 0xEF, 0x30, 0xBB, 0x8A, 0xDE, 0xEB, 0x21, 0x75, 0x24, 0xF1, 0xDB, 0x1F, 0x9E, 0x33,
  0x17, 0xD6, 0x59, 0x39, 0x73, 0x4C, 0xA5, 0xD7, 0x40, 0x97, 0x12, 0xEE, 0xAF, 0x0E, 0xB7, 0x8C,
  0xE8, 0xCF, 0x63, 0xC7, 0xD8, 0xAD, 0x3B, 0xB7, 0x36, 0xF7, 0x46, 0x52, 0x74, 0x03, 0xB6, 0xED,
  0xDD, 0xCE, 0xCD, 0x44, 0xFF, 0xB5, 0x8E, 0x71, 0x45, 0x3B, 0xAA, 0x0C, 0x44, 0x43, 0xC1, 0xFB,
  0x0C, 0xF2, 0x47, 0xB0, 0x72, 0xAA, 0xB4, 0x68, 0xB4, 0x24, 0x8F, 0xAA, 0x5F, 0x56, 0xFD, 0xBC,
  0xB3, 0xA5, 0x14, 0xD6, 0x4B, 0x70, 0x6A, 0xDE, 0x4A, 0xD3, 0xEC, 0x4B, 0xFE, 0x80, 0x00, 0xAB,
  0xFA, 0xCC, 0x60, 0x23, 0x5A, 0x49, 0x24, 0x52, 0xD7, 0x10, 0xAC, 0x56, 0x51, 0x59, 0x64, 0xD7,
  0x9B, 0x09, 0x37, 0xAC, 0x5D, 0x88, 0xDD, 0x9E, 0x57, 0x6D, 0x2F, 0x06, 0xAB, 0xDA, 0x40, 0x17,
  0x30, 0xEF, 0xEC, 0xDC, 0xAE, 0xE2, 0xE3, 0xBC, 0x54, 0xC7, 0x95, 0x20, 0x9E, 0xDE, 0x1D, 0x5D,
  0x03, 0x2F, 0x80, 0x88, 0xAB, 0x36, 0x76, 0xA4, 0xD8, 0x44, 0xC1, 0xBE, 0x30, 0x7B, 0xA3, 0x25,
  0x5F, 0x77, 0x91, 0x98, 0x64, 0xAB, 0xFC, 0x2B, 0x13, 0x5C, 0x2C, 0x40, 0x76, 0x91, 0x60, 0xBB,
  0x61, 0xDE, 0x44, 0x76, 0x0A, 0x35, 0x0C, 0x73, 0xDA, 0x11, 0x61, 0x58, 0xD8, 0x33, 0x9F, 0x0C,
  0x1A, 0x50, 0x7D, 0x10, 0xB8, 0xB2, 0xBC, 0x43, 0x59, 0xED, 0xC6, 0x3F, 0x4F, 0xC8, 0x3C, 0xE5,
  0xD5, 0x0A, 0x4F, 0xFA, 0x3A, 0xF7, 0x59, 0xEC, 0x47, 0xF5, 0x28, 0x55, 0xDB, 0x3A, 0x77, 0xA4,
  0x3D, 0x26, 0xB9, 0x7F, 0xB6, 0x3E, 0x5E, 0x4E, 0xDE, 0xB0, 0x87, 0xE5, 0xD6, 0xCC, 0x41, 0x26,
  0xB4, 0xB0, 0xDB, 0xF8, 0x4C, 0x22, 0xE7, 0x7B, 0xD5, 0x77, 0x23, 0x0E, 0x36, 0x46, 0x46, 0x16,
  0xBD, 0x91, 0xE6, 0x45, 0x65, 0xB3, 0x89, 0x6D, 0xED, 0x27, 0xAB, 0x95, 0x05, 0x35, 0x70, 0xEE,
  0xF3, 0xCC, 0xCB, 0x60, 0x16, 0xFC, 0xB1, 0x10, 0x64, 0x0B, 0x94, 0xCF, 0x5A, 0x13, 0xBA, 0x0C,
  0x23, 0xE0, 0x92, 0xF1, 0xB8, 0x61, 0xA4, 0xAA, 0x48, 0xC0, 0xCE, 0x80, 0x54, 0x00, 0x58, 0xFF,
  0x6E, 0x0B, 0xB5, 0x2A, 0x55, 0xE3, 0x6D, 0xD2, 0x6D, 0x60, 0xAB, 0x70, 0x6E, 0x07, 0x95, 0x67,
  0x04, 0xBD, 0x75, 0x39, 0x63, 0x08, 0x84, 0x0C, 0x44, 0x86, 0x73, 0xE5, 0x69, 0x8F, 0x10, 0xCF,
  0x4A, 0xF0, 0xA7, 0x88, 0xA7, 0xD2, 0xBA, 0x6D, 0x5D, 0x45, 0xD1, 0x2D, 0x45, 0xEA, 0xFC, 0x21,
  0xB6, 0x91, 0x51, 0x50, 0x28, 0x47, 0x82, 0x49, 0xF8, 0x9E, 0x9E, 0xDB, 0xAC, 0xE7, 0xA6, 0x87,
  0xB7, 0x36, 0x7B, 0x39, 0xE0, 0xC1, 0x79, 0x7F, 0x45, 0xB9, 0xF7, 0x78, 0x7A, 0x0D, 0xCA, 0x39,
  0x59, 0xC5, 0x94, 0x80, 0xD4, 0x53, 0x08, 0xA1, 0x27, 0x3E, 0x65, 0x81, 0x23, 0x21, 0x0F, 0xEF,
  0xA0, 0x77, 0xFD, 0x99, 0xB7, 0x13, 0x6E, 0x49, 0x3F, 0x80, 0x05, 0xAC, 0x76, 0xA5, 0x15, 0x0E,
  0x07, 0xBF, 0x1C, 0xE3, 0xAB, 0x49, 0x11, 0x97, 0xBA, 0x18, 0xDA, 0x5C, 0xDF, 0x94, 0xD2, 0xC6,
  0xFB, 0xCA, 0xE1, 0xF9, 0xCE, 0x7F, 0xD5, 0x25, 0xCF, 0xA5, 0x7D, 0xB7, 0x34, 0x9E, 0x17, 0x4F,
  0xED, 0x2B, 0x11, 0x54, 0x03, 0x7A, 0x7A, 0xE0, 0x57, 0x36, 0xAA, 0xDB, 0x51, 0x7E, 0xD9, 0xA1,
  0x7F, 0xCE, 0xF9, 0xB7, 0x73, 0x40, 0x57, 0x3A, 0x45, 0x04, 0x71, 0xD3, 0xF6, 0x2F, 0x9E, 0xD4,
  0xCD, 0x5A, 0xD4, 0x89, 0x90, 0x85, 0xC6, 0xF8, 0x54, 0x1C, 0x5F, 0xB0, 0x70, 0xBD, 0xFB, 0x54,
  0x96, 0x16, 0xF5, 0x88, 0xE0, 0x06, 0x13, 0x81, 0xD5, 0xC5, 0xF6, 0xB5, 0x2B, 0xC7, 0xBD, 0x42,
  0xE6, 0x68, 0x74, 0x45, 0xE3, 0x89, 0x46, 0x2E, 0xE4, 0xE3, 0x05, 0x82, 0x9C, 0xF2, 0x6F, 0xEA,
  0x99, 0x98, 0xC1, 0x0F, 0x46, 0xBA, 0x9B, 0x8E, 0xD0, 0xBB, 0x6C, 0xF3, 0x89, 0x24, 0xEC, 0x4C,
  0x79, 0xFB, 0xB4, 0xCC, 0x76, 0x90, 0xCA, 0xED, 0xE2, 0x0D, 0x48, 0xD3, 0x63, 0x59, 0xD6, 0xFB,
  0xAD, 0xFE, 0x64, 0x95, 0xBF, 0x36, 0xD7, 0x24, 0x13, 0x4D, 0xD0, 0x6F, 0xAF, 0xD8, 0x17, 0xAF,
  0xBC, 0x3F, 0xB8, 0x4E, 0xB7, 0x67, 0x1F, 0x53, 0x43, 0x6D, 0x07, 0xCC, 0x84, 0x25, 0xAC, 0x16,
  0xA7, 0x0E, 0xC7, 0x4C, 0xE1, 0xF0, 0x1B, 0xEA, 0xBD, 0x07, 0xFC, 0x9D, 0x0B, 0xA2, 0x6F, 0xE7,
  0xC8, 0xFF, 0x13, 0x27, 0xF6, 0xCD, 0x34, 0xFF, 0xBC, 0x6B, 0x15, 0x67, 0x15, 0xCE, 0x4F, 0xE6,
  0x25, 0xAD, 0x01, 0xF2, 0x24, 0x13, 0x1D, 0x2B, 0xBB, 0xF2, 0xF8, 0x2C, 0xE1, 0x23, 0x7F, 0xD9,
  0xCA, 0xF2, 0xF3, 0xB5, 0x22, 0x31, 0xFF, 0x4C, 0x21, 0x2B, 0x04, 0xB8, 0xD4, 0xAF, 0xAC, 0x32,
  0x1B, 0xAE, 0x5D, 0xEB, 0xCE, 0x29, 0xF6, 0x8E, 0xBB, 0x4C, 0xF3, 0x64, 0xE0, 0x16, 0xDB, 0xA3,
  0x29, 0xF7, 0xCC, 0xCE, 0x7A, 0xA8, 0xE7, 0x76, 0x3E, 0x3D, 0xE9, 0x17, 0x6A, 0x55, 0x5B, 0xBF,
  0xA5, 0xA3, 0x89, 0x75, 0x9B, 0x43, 0x9D, 0x3A, 0x89, 0x0D, 0x33, 0x56, 0xFF, 0x4C, 0xE5, 0xCB,
  0x21, 0xAE, 0x3B, 0x06, 0xB7, 0x3A, 0x81, 0xCF, 0x45, 0xC8, 0xC9, 0x2C, 0xC7, 0xD0, 0x06, 0xF0,
  0xC3, 0xBE, 0x9D, 0x13, 0xA9, 0x69, 0xF5, 0x70, 0x4D, 0xC7, 0xD3, 0x72, 0xC7, 0xDA, 0xB6, 0x61,
  0x65, 0x6E, 0x84, 0xA3, 0xE0, 0xDC, 0x32, 0x8E, 0xB7, 0x1B, 0x9F, 0xDF, 0xAD, 0xD5, 0x2B, 0x3C,
  0x24, 0x00, 0xE2, 0xAE, 0x1A, 0x3C, 0x0A, 0x78, 0x85, 0x6D, 0x66, 0x5E, 0x15, 0xAE, 0x9E, 0x73,
  0x02, 0xE5, 0x6B, 0x17, 0x19, 0xF6, 0xEC, 0x81, 0x1F, 0x5D, 0x21, 0xB6, 0xF0, 0x06, 0x77, 0x65,
  0xD8, 0x3D, 0x4E, 0x9D, 0x28, 0xD8, 0xC5, 0x82, 0x77, 0x89, 0x7E, 0x9B, 0x07, 0xA2, 0x88, 0x59,
  0xE6, 0xDD, 0x85, 0x13, 0x80, 0x73, 0xE3, 0x0D, 0x87, 0xC5, 0x48, 0x49, 0x8F, 0xAF, 0xE2, 0xB7,
  0x36, 0x55, 0x2B, 0x08, 0xFA, 0xB4, 0x30, 0x5F, 0xC3, 0x53, 0x5A, 0xC3, 0xE5, 0x98, 0x59, 0xD3,
  0xEA, 0x5B, 0x7A, 0x97, 0x3B, 0xD9, 0xEF, 0x8C, 0xF9, 0x6C, 0x50, 0x9A, 0x43, 0xC7, 0xE0, 0xAC,
  0x17, 0x80, 0xB1, 0x84, 0x18, 0x4B, 0x14, 0x58, 0x13, 0x97, 0x5B, 0x6D, 0x60, 0xD6, 0x53, 0x65,
  0x15, 0xB1, 0x30, 0xFF, 0x72, 0xE0, 0x72, 0x43, 0x0A, 0xE0, 0xF3, 0xBB, 0xE7, 0xF3, 0x51, 0x46,
  0x8F, 0xA2, 0x9D, 0xE4, 0x56, 0x15, 0xD5, 0xA9, 0x28, 0x92, 0x08, 0xBA, 0x08, 0x48, 0x93, 0x67,
  0x9B, 0x68, 0x9A, 0x89, 0x22, 0xB3, 0x56, 0x0E, 0xA2, 0x3B, 0x49, 0xDD, 0x21, 0x62, 0x8A, 0x24,
  0x45, 0xCB, 0xD6, 0x60, 0x7A, 0xE3, 0x29, 0xB7, 0x23, 0xCB, 0x9F, 0xF2, 0x3A, 0xCE, 0x06, 0xC5,
  0xCA, 0x43, 0xAE, 0xE2, 0x03, 0x3C, 0x8E, 0xFE, 0x1D, 0x12, 0x53, 0x50, 0x19, 0xBF, 0x3E, 0xD5,
  0x2F, 0xAF, 0x62, 0x64, 0x7A, 0xC1, 0xC7, 0x4E, 0xEF, 0x23, 0xAC, 0xA1, 0xC1, 0xD4, 0xDB, 0x91,
  0x62, 0x1C, 0xE1, 0x36, 0x1E, 0xC0, 0x2D, 0x14, 0x4A, 0x80, 0x8A, 0xA6, 0x56, 0x2F, 0x1D, 0x03,
  0x66, 0x84, 0x40, 0xEE, 0x9A, 0xFD, 0xF3, 0x03, 0x5E, 0x08, 0x4A, 0x7B, 0xE7, 0x4D, 0x16, 0x90,
  0x04, 0x76, 0xF7, 0x4C, 0x06, 0xCC, 0x47, 0xD4, 0xC6, 0x9F, 0xD1, 0x5A, 0xBF, 0x21, 0xC6, 0x6F,
  0xF2, 0x25, 0x36, 0xE4, 0xB8, 0xDD, 0x33, 0xB1, 0x46, 0xEA, 0xB1, 0x1E, 0x85, 0x26, 0x4B, 0x33,
  0x17, 0xF1, 0x9F, 0x4E, 0x6B, 0x09, 0x55, 0xEA, 0x06, 0xF4, 0x15, 0x56, 0xD3, 0x27, 0x72, 0xDC,
  0xC2, 0xA3, 0xC0, 0xCD, 0x87, 0x85, 0xB3, 0x8D, 0x1F, 0x02, 0x3C, 0xC6, 0x1D, 0x4D, 0xC9, 0xAB,
  0xB5, 0xD1, 0xE6, 0xCB, 0xD9, 0x0E, 0xA6, 0x0B, 0x03, 0x4F, 0x97, 0x68, 0x25, 0x8F, 0x50, 0x9F,
  0x29, 0x34, 0xF8, 0xA8, 0x4E, 0xD2, 0xE0, 0x1D, 0x99, 0x6A, 0xE5, 0xC8, 0x25, 0x96, 0x2F, 0xDD,
  0x25, 0xEB, 0x97, 0x9C, 0xEA, 0x53, 0xF6, 0x8D, 0x5A, 0x35, 0xAB, 0xEE, 0x8F, 0x43, 0x87, 0xC5,
  0xAA, 0x84, 0x15, 0x44, 0xAE, 0x27, 0xE3, 0xCD, 0xFD, 0xB8, 0x3D, 0xAA, 0xE8, 0xE7, 0x04, 0x41,
  0x5A, 0x39, 0xDB, 0x8B, 0x8F, 0xD5, 0xA2, 0x80, 0x92, 0xF3, 0x2D, 0xBE, 0xBC, 0xAC, 0x54, 0xCB,
  0xB7, 0xBE, 0xEC, 0xA5, 0xA3, 0x22, 0x1D, 0xEF, 0x25, 0x76, 0xD3, 0xBE, 0xAD, 0x2F, 0x5F, 0xCF,
  0x71, 0x4A, 0x31, 0x1A, 0x75, 0x3D, 0x78, 0x2C, 0x6A, 0xB8, 0x9F, 0x7C, 0x80, 0xE6, 0xFC, 0xCA,
  0x04, 0x70, 0x5F, 0xF2, 0x2F, 0x87, 0x50, 0x9F, 0xDB, 0xEE, 0x5A, 0x84, 0x68, 0x7D, 0x48, 0x81,
  0x49, 0x65, 0xD1, 0x8C, 0xBA, 0x16, 0x0C, 0xFC, 0xFA, 0xA0, 0x1C, 0x8D, 0x83, 0x8C, 0x00, 0x4E,
  0x75, 0x0A, 0x4A, 0x60, 0x3E, 0x25, 0xEB, 0x3A, 0xBA, 0x69, 0x10, 0x74, 0x77, 0x3B, 0x82, 0x83,
  0xDD, 0xE5, 0x49, 0xB9, 0x1B, 0xBA, 0x8A, 0x2E, 0x35, 0xFA, 0x7C, 0xAA, 0x27, 0xE6, 0xB2, 0x7B,
  0xAA, 0x97, 0x39, 0x9F, 0x0B, 0x29, 0x73, 0x0C, 0x80, 0x84, 0x3B, 0xC3, 0x7A, 0x04, 0x6F, 0x03,
  0xCB, 0x80, 0x9A, 0xA9, 0x5D, 0xE6, 0x3C, 0xAF, 0x90, 0x2E, 0xB7, 0xEB, 0x55, 0xE6, 0xF9, 0x10,
  0x66, 0xA2, 0x35, 0xF5, 0xB8, 0x24, 0x43, 0xA0, 0xBC, 0x74, 0xD3, 0xBA, 0x5D, 0x3C, 0x54, 0xE0,
  0xFB, 0xA7, 0xBF, 0xE6, 0xB8, 0xA4, 0xC2, 0xFB, 0xD9, 0xC0, 0x97, 0xB3, 0x1B, 0x3A, 0x6C, 0x25,
  0xDB, 0xBD, 0x77, 0x38, 0x3C, 0xB1, 0xBC, 0xC1, 0xAD, 0xA6, 0x76, 0x09, 0x3D, 0xBF, 0xC5, 0x78,
  0x3F, 0xCE, 0x77, 0x77, 0x74, 0x5D, 0xCB, 0xD8, 0x31, 0x6C, 0xC6, 0x48, 0x5A, 0xD5, 0x6D, 0x3C,
  0x3B, 0x9F, 0xC1, 0x64, 0x21, 0x34, 0xFF, 0x08, 0x7E, 0xE5, 0xE4, 0x30, 0xCB, 0x2B, 0x92, 0x8A,
  0xC9, 0xA2, 0x3C, 0xDE, 0x3A, 0xEB, 0x9D, 0x5F, 0x80, 0x04, 0x4A, 0xB6, 0xEF, 0x29, 0x1E, 0x1C,
  0x4D, 0xA7, 0x7F, 0xC1, 0x92, 0x5B, 0xDB, 0xF3, 0x1C, 0xF4, 0x7A, 0x09, 0x39, 0x11, 0x12, 0x4F,
  0xEF, 0x41, 0x2D, 0xDC, 0xEE, 0x7B, 0xF6, 0x20, 0x4A, 0x34, 0x31, 0x99, 0xFC, 0xEE, 0xA5, 0xB1,
  0xB8, 0x87, 0xA1, 0xB2, 0x7D, 0x3C, 0x1A, 0x55, 0xE4, 0x26, 0x03, 0x3C, 0x28, 0xB6, 0x51, 0x9A,
  0x6A, 0x8D, 0x72, 0x83, 0x94, 0x51, 0x87, 0x89, 0x3D, 0x63, 0xDF, 0x6C, 0xFB, 0x40, 0xC4, 0x2F,
  0xE7, 0x46, 0x90, 0xA4, 0xDD, 0x62, 0x83, 0x7D, 0x54, 0xED, 0x06, 0xC9, 0xA3, 0xCE, 0x42, 0x6E,
  0xF5, 0xAB, 0x2B, 0xC3, 0x60, 0xD4, 0xF1, 0x21, 0x0F, 0x73, 0x72, 0xB4, 0x9B, 0x03, 0x71, 0xFF,
  0xCE, 0x86, 0xA6, 0xB7, 0x71, 0xA4, 0x7C, 0xCC, 0x9B, 0xA0, 0x06, 0xD1, 0xD6, 0x1B, 0x98
};
// EGG_DATA_END

// kunci aliran: tanpa state, tergantung posisi byte (obfuscation, BUKAN enkripsi kuat)
static uint8_t eggKey(uint16_t i) {
  uint32_t x = (uint32_t)i * 2654435761u; x ^= x >> 15;
  x *= 2246822519u; x ^= x >> 13;
  return (uint8_t)(x >> 8) ^ 0x5A;
}

static bool           aboutEggOpen  = false;
static uint8_t        eggTaps       = 0;
static unsigned long  eggLastTap    = 0;
static uint16_t       eggLnOff[EGG_MAX_LINES];   // offset awal baris di EGG_BLOB
static uint8_t        eggLnLen[EGG_MAX_LINES];
static uint16_t       eggLnCum[EGG_MAX_LINES];   // total karakter sampai akhir baris i
static int            eggLnN        = 0;
static int            eggTotal      = 0;
static int            eggChars      = 0;         // karakter isi cerita yang sudah "diketik"
static int            eggCmdChars   = 0;         // karakter perintah yang sudah diketik
static unsigned long  eggT0         = 0;
static float          eggScroll     = 0;
static int            eggMaxScroll  = 0;
static int            eggLastY      = 0;
static bool           eggDragging   = false;
static bool           eggAuto       = true;
static uint8_t        eggBlink      = 0;

static int eggViewTop()    { return 20; }
static int eggViewBottom() { return SCR_H - BACK_H - 3 - 6; }

// pecah paragraf jadi baris sesuai lebar layar (sekali saat dibuka)
static void eggBuildLines() {
  int maxCh = (SCR_W - 16) / 6; if (maxCh < 16) maxCh = 16; if (maxCh > 120) maxCh = 120;
  eggLnN = 0; eggTotal = 0;
  for (int p = 0; p < EGG_PN && eggLnN < EGG_MAX_LINES - 1; p++) {
    char t[EGG_MAX_PARA];                                // paragraf didekode sementara (stack)
    int tl = (int)EGG_PL[p], pos = 0;
    if (tl > EGG_MAX_PARA - 1) tl = EGG_MAX_PARA - 1;
    for (int k = 0; k < tl; k++) t[k] = (char)(EGG_BLOB[EGG_PO[p] + k] ^ eggKey((uint16_t)(EGG_PO[p] + k)));
    while (pos < tl && eggLnN < EGG_MAX_LINES - 1) {
      int len = tl - pos;
      if (len > maxCh) {
        len = maxCh;
        int b = len;
        while (b > 0 && t[pos + b] != ' ') b--;      // mundur ke spasi terakhir
        if (b > 0) len = b;
      }
      eggLnOff[eggLnN] = (uint16_t)(EGG_PO[p] + pos); eggLnLen[eggLnN] = (uint8_t)len;
      eggTotal += len; eggLnCum[eggLnN] = (uint16_t)eggTotal; eggLnN++;
      pos += len;
      while (pos < tl && t[pos] == ' ') pos++;
    }
    memset(t, 0, sizeof(t));                             // hapus teks polos dari stack
    if (eggLnN < EGG_MAX_LINES) {                        // baris kosong antar paragraf
      eggLnOff[eggLnN] = 0; eggLnLen[eggLnN] = 0; eggLnCum[eggLnN] = (uint16_t)eggTotal; eggLnN++;
    }
  }
  // isi: 1 baris perintah + baris cerita + baris "exit" + baris prompt akhir
  int contentH = (eggLnN + 3) * EGG_LINE_H, viewH = eggViewBottom() - eggViewTop();
  eggMaxScroll = contentH - viewH; if (eggMaxScroll < 0) eggMaxScroll = 0;
}

static void eggOpen() {
  eggBuildLines();
  eggChars = 0; eggCmdChars = 0; eggT0 = millis(); eggScroll = 0; eggAuto = true; eggDragging = false; eggBlink = 0;
  aboutEggOpen = true; eggTaps = 0;
  needRedraw = true;
}

// hitung kemajuan ketikan dari waktu (tidak bergantung kecepatan frame)
static void eggUpdateProgress() {
  unsigned long el = millis() - eggT0;
  int cl = (int)strlen(EGG_CMD);
  unsigned long cmdMs = (unsigned long)cl * 1000UL / EGG_CMD_CPS;
  if (el < cmdMs) { eggCmdChars = (int)(el * EGG_CMD_CPS / 1000UL); eggChars = 0; return; }
  eggCmdChars = cl;
  unsigned long b = el - cmdMs;
  if (b < (unsigned long)EGG_PAUSE_MS) { eggChars = 0; return; }
  b -= EGG_PAUSE_MS;
  unsigned long n = b * EGG_CPS / 1000UL;
  eggChars = (n > (unsigned long)eggTotal) ? eggTotal : (int)n;
}

static bool eggDone() { return eggCmdChars >= (int)strlen(EGG_CMD) && eggChars >= eggTotal; }

// dipanggil tiap iterasi loop saat About terbuka (lewat aboutLoopPoll)
static void eggTick() {
  int pc = eggChars, pm = eggCmdChars;
  eggUpdateProgress();
  bool changed = (eggChars != pc) || (eggCmdChars != pm);
  if (changed && eggAuto) {                              // ikuti baris yang sedang diketik
    int bottomY;
    if (eggDone()) bottomY = (eggLnN + 3) * EGG_LINE_H;
    else { int li = 0; while (li < eggLnN - 1 && eggLnCum[li] < eggChars) li++; bottomY = (li + 2) * EGG_LINE_H; }
    int viewH = eggViewBottom() - eggViewTop();
    float want = (float)(bottomY - viewH); if (want < 0) want = 0; if (want > eggMaxScroll) want = (float)eggMaxScroll;
    eggScroll = want;
  }
  uint8_t bl = (uint8_t)((millis() / 500UL) & 1);        // kursor berkedip 2x per detik
  if (changed || bl != eggBlink) { eggBlink = bl; needRedraw = true; }
}

static void eggDraw(LGFX_Sprite& s) {
  s.fillRect(0, 0, SCR_W, SCR_H, EGG_C_BG);
  s.fillRect(0, 0, SCR_W, 16, EGG_C_BAR);                // bar judul terminal
  s.setTextSize(1); s.setTextColor(EGG_C_BARTXT);
  s.setCursor(6, 4); s.print("nyx@accretion: ~");

  int top = eggViewTop(), bot = eggViewBottom();
  s.setClipRect(0, top, SCR_W, bot - top);
  s.setTextSize(1);
  int y0 = top - (int)eggScroll;
  const int LH = EGG_LINE_H, X0 = 8;
  const int pl = (int)strlen(EGG_PROMPT), cl = (int)strlen(EGG_CMD);
  int curX = X0, curY = y0;                              // posisi kursor

  // baris 0: prompt + perintah yang sedang diketik
  s.setTextColor(EGG_C_PROMPT); s.setCursor(X0, y0 + 1); s.print(EGG_PROMPT);
  { char cb[40]; int n = eggCmdChars; if (n > cl) n = cl; if (n > (int)sizeof(cb) - 1) n = (int)sizeof(cb) - 1;
    memcpy(cb, EGG_CMD, n); cb[n] = 0;
    s.setTextColor(EGG_C_TEXT); s.print(cb);
    curX = X0 + (pl + n) * 6; curY = y0; }

  // baris cerita
  char buf[130];
  for (int i = 0; i < eggLnN; i++) {
    int ry = y0 + (i + 1) * LH;
    int len = eggLnLen[i]; if (len == 0) continue;
    int startCum = (int)eggLnCum[i] - len;
    int show = eggChars - startCum;
    if (show <= 0) continue;
    if (show > len) show = len;
    if (show > (int)sizeof(buf) - 1) show = (int)sizeof(buf) - 1;
    curX = X0 + show * 6; curY = ry;
    if (ry + LH < top || ry > bot) continue;
    for (int k = 0; k < show; k++) buf[k] = (char)(EGG_BLOB[eggLnOff[i] + k] ^ eggKey((uint16_t)(eggLnOff[i] + k)));
    buf[show] = 0;
    s.setTextColor(i >= eggLnN - 3 ? EGG_C_WARN : EGG_C_TEXT);   // paragraf penutup beraksen
    s.setCursor(X0, ry + 1); s.print(buf);
  }

  // setelah selesai: baris exit + prompt akhir
  if (eggDone()) {
    int ey = y0 + (eggLnN + 1) * LH, py = y0 + (eggLnN + 2) * LH;
    s.setTextColor(EGG_C_WARN); s.setCursor(X0, ey + 1); s.print("[process exited with code 1]");
    s.setTextColor(EGG_C_PROMPT); s.setCursor(X0, py + 1); s.print(EGG_PROMPT);
    curX = X0 + pl * 6; curY = py;
  }
  if (eggBlink || !eggDone()) s.fillRect(curX, curY + 1, 5, 8, EGG_C_PROMPT);   // kursor blok

  s.clearClipRect();
  if (eggMaxScroll > 0) {
    int trackH = bot - top;
    int thumbH = trackH * trackH / (trackH + eggMaxScroll); if (thumbH < 12) thumbH = 12;
    int thumbY = top + (int)((trackH - thumbH) * (eggScroll / (float)eggMaxScroll));
    s.fillRect(SCR_W - 3, thumbY, 2, thumbH, 0x03E0);
  }
  drawBack(s);
  drawToast(s);
}

static void eggTouch(int x, int y, bool held, bool isNew) {
  if (isNew) {
    if (isBack(x, y)) { aboutEggOpen = false; eggDragging = false; needRedraw = true; return; }
    if (!eggDone()) { eggT0 = millis() - 60000UL; eggUpdateProgress(); needRedraw = true; }   // ketuk = lewati animasi ketik
    eggAuto = false;
    eggDragging = (y >= eggViewTop() && y <= eggViewBottom());
    eggLastY = y;
    return;
  }
  if (!held) { eggDragging = false; return; }
  if (!eggDragging) return;
  int dy = eggLastY - y; eggLastY = y;
  if (dy == 0) return;
  eggScroll += (float)dy;
  if (eggScroll < 0) eggScroll = 0;
  if (eggScroll > eggMaxScroll) eggScroll = (float)eggMaxScroll;
  needRedraw = true;
}

// ---------------------------------------------------------------------
// siklus app
// ---------------------------------------------------------------------
void aboutEnter() {
  aboutEggOpen = false; eggTaps = 0; eggDragging = false;   // EGG_ABOUT_V1
  aboutScroll = 0;
  aboutDragging = false;
  aboutRefresh();
  aboutClampScroll();
  aboutLastPoll = millis();
}

void aboutExit() {
  aboutDragging = false;
}

// dipanggil dari loop() phone.ino -- refresh angka live tiap 1 detik
void aboutLoopPoll() {
  if (aboutEggOpen) { eggTick(); return; }                 // EGG_ABOUT_V1
  if (millis() - aboutLastPoll < 1000UL) return;
  aboutLastPoll = millis();
  if (aboutDragging) return;           // jangan ganggu scroll yang sedang berjalan
  aboutRefresh();
  aboutClampScroll();
  needRedraw = true;
}

// ---------------------------------------------------------------------
// gambar
// ---------------------------------------------------------------------
void drawAbout(LGFX_Sprite& s) {
  if (aboutEggOpen) { eggDraw(s); return; }                // EGG_ABOUT_V1
  iosBackdrop(s);
  drawStatusBar(s);
  iosTitle(s, 8, 26, "About Phone");

  // ---- kartu identitas ----
  int cx = 8, cy = 26 + 18, cw = SCR_W - 16;
  drawGlassPanel(s, cx, cy, cw, ABOUT_CARD_H, 12, T().surface2, 170);

  // logo kecil: cakram accretion (lingkaran gelap + cincin aksen)
  int lr = 15, lx = cx + 10 + lr, ly = cy + ABOUT_CARD_H / 2;
  if (ownerHasAvatar()) {
    ownerDrawAvatar(s, lx, ly, lr + 4);              // foto pemilik menggantikan logo
  } else {
    nyxAaCircle(s, lx, ly, lr, T().bg);
    nyxAaCircleRing(s, lx, ly, lr, T().accent);
    nyxAaCircleRing(s, lx, ly, lr - 3, T().accent2);
    nyxAaCircle(s, lx, ly, 5, T().bg);
    s.fillEllipse(lx, ly, lr + 4, 3, T().accent);   // cincin miring
    nyxAaCircle(s, lx, ly, 4, T().bg);
  }

  int tx = lx + lr + 12;
  s.setTextSize(2); s.setTextColor(T().text);
  s.setCursor(tx, cy + 10); s.print(ABOUT_DEVICE_NAME);
  s.setTextSize(1); s.setTextColor(T().accent);
  s.setCursor(tx, cy + 32); s.print(ABOUT_OS_NAME);
  s.setTextColor(T().subtext);
  s.print("  ");
  { char vl[16]; otaVersionLabel(vl, sizeof(vl)); s.print(vl); }

  // ---- daftar info (di-clip supaya tidak menimpa judul / tombol Kembali) ----
  int top = aboutListTop(), bot = aboutListBottom();
  s.setClipRect(0, top, SCR_W, bot - top);
  s.setTextSize(1);
  int keyX = 12;
  int valX = SCR_W * 2 / 5; if (valX < 110) valX = 110;
  int y0 = top - (int)aboutScroll;
  for (int i = 0; i < aboutRowN; i++) {
    int ry = y0 + i * ABOUT_ROW_H;
    if (ry + ABOUT_ROW_H < top || ry > bot) continue;   // di luar layar, lewati
    s.setTextColor(T().subtext);
    s.setCursor(keyX, ry + 6); s.print(aboutRows[i].k);
    s.setTextColor(T().text);
    s.setCursor(valX, ry + 6); s.print(aboutRows[i].v);
    if (i < aboutRowN - 1) s.drawFastHLine(keyX, ry + ABOUT_ROW_H - 1, SCR_W - 2 * keyX, T().divider);
  }
  s.clearClipRect();

  // scrollbar tipis kalau konten lebih panjang dari area tampil
  if (aboutMaxScroll > 0) {
    int trackH = bot - top;
    int thumbH = trackH * trackH / (trackH + aboutMaxScroll); if (thumbH < 12) thumbH = 12;
    int thumbY = top + (int)((trackH - thumbH) * (aboutScroll / (float)aboutMaxScroll));
    nyxAaRR(s, SCR_W - 4, thumbY, 2, thumbH, 1, blend565(T().bg, T().text, 90));
  }

  drawBack(s);
  drawToast(s);
}

// ---------------------------------------------------------------------
// sentuh: Kembali + drag-scroll
// ---------------------------------------------------------------------
void aboutTouch(int x, int y, bool held, bool isNew) {
  if (aboutEggOpen) { eggTouch(x, y, held, isNew); return; }   // EGG_ABOUT_V1
  if (isNew) {
    if (isBack(x, y)) { navBack(); return; }
    // EGG_ABOUT_V1: 7x ketuk kartu identitas -> cerita tersembunyi
    if (y >= 26 + 18 && y <= 26 + 18 + ABOUT_CARD_H) {
      unsigned long now = millis();
      if (now - eggLastTap > 1500UL) eggTaps = 0;
      eggLastTap = now;
      if (++eggTaps >= 7) { eggOpen(); return; }
    }
    aboutDragging = (y >= aboutListTop() && y <= aboutListBottom());
    aboutLastY = y;
    return;
  }
  if (!held) { aboutDragging = false; return; }
  if (!aboutDragging) return;

  int dy = aboutLastY - y;
  aboutLastY = y;
  if (dy == 0) return;
  aboutScroll += (float)dy;
  aboutClampScroll();
  needRedraw = true;
}
